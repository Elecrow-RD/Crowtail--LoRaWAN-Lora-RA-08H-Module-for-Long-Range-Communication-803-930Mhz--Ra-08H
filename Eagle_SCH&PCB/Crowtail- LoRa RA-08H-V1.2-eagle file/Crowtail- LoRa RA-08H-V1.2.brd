# Repository Elecrow-RD/Crowtail--LoRaWAN-Lora-RA-08H-Module-for-Long-Range-Communication-803-930Mhz--Ra-08H

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | latest |

### 3, product information

#### Display Module Specifications

- Voltage: 3.3~5V
- Theoretical maximum transmission power+22dBm
- Supported frequency band: 803~930MHZ
- High sensitivity: -138dBm@125KzSF12
- Support spread spectrum factor: SF5/SF6/SF7/SF8/SF9/SF10/SF11/SF12
- Embedded memory: 128KB FLASH, 16KB SRAM
- Support LoRa/(G) FSK/BPSK/(G) MSK modulation
- Maximum transmission distance 1KM (ideal value for open space)
- With download and communication switching functions, users can customize programming
- Configure the first-generation IPEX seat
- Dimension (mm): 40 (L) * 20 (W) * 7.5 (H)

### 

### 4,Quick Start

##### Arduino IDE starts

STEP1 Configure controller board&communication port
On top of the Arduino IDE, click “Tools>Board>” and select “Arduino Uno” from the available options

STEP2 Select the COM port that indicates Arduino Uno. Please note that the actual numbers after the “COM” word will vary from computer to computer, so they could be different from the ones shown in the figure.

### 6,Folder structure.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

### 7,Pin definition

// Pin2——>LORA-TXD

// Pin3——>LORA-RXD

## EAGLE design Eagle_SCH&PCB/Crowtail- LoRa RA-08H-V1.2-eagle file/Crowtail- LoRa RA-08H-V1.2.brd

Parts:
C1, C2, C4: 10uF; C0805
C3, C5, C6: 100nF; C0603
C7: 330pF; C0603
J1: TWIG-4P-2.0-SMD-FEMALE-REINFORCE'90D'; 4P-SMD-2.0-90D
J2: U.FL
LED1: RED; LED-0603
LED2: BLUE; LED-0603
LED3: GREEN; LED-0603
Q1, Q2: 2N7002; SOT23
R1: 2K; 0603
R2, R3: 510R; 0603
R4, R5, R6, R7: 4.7K; DISCRETE_R0603
R8: 10K; DISCRETE_R0603
R9, R10: 10K/NC; DISCRETE_R0603
U1: RA-08H; RA-08H-SMD-18
U2: AMS1117-3.3; AMS1117-3.3-SOT223

Connections:
3V3: C2.2, C3.2, C4.2, C5.2, LED2.+, LED3.+, Q1.1 (G), Q2.1 (G), R1.1, R4.1, R6.1, R8.2, R9.2, R10.2, U1.9 (VCC), U2.2 (2-VOUT), U2.4 (4-TAB)
5V: C1.2, C6.2, J1.3, R5.1, R7.1, R10.1, U2.3 (3-VIN)
ANT: J2.P$3 (SIGNAL), U1.18 (ANT)
BT_RX: J1.2, Q2.3 (D), R5.2
BT_TX: J1.1, Q1.3 (D), R7.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, J1.4, J1.SS1, J1.SS2, J2.P$1 (GND), J2.P$2 (GND), LED1.-, U1.1 (1-GND), U1.17 (17-GND), U2.1 (1-GND)
LPUART-RX: Q2.2 (S), R3.1, R4.2, U1.10 (LPUART-RX/IO6)
unnamed: LED2.-, R2.2
unnamed: LED1.+, R1.2
unnamed: LED3.-, R3.2
unnamed: R9.1, U1.15 (BOOT/IO2)
REST: C7.2, R8.1, U1.16 (RESET)
UART-RX: U1.12 (U0RX/IO16)
UART-TX: Q1.2 (S), R2.1, R6.2, U1.11 (U0TX/IO17)

Notes on the sheet:
Uart Port
指示灯
5V转3.3V
RA-08H主控
UART串口

Board: 2 copper layers, 40.5 x 20.0 mm, 26 parts (0 on the bottom side), 13 nets.
